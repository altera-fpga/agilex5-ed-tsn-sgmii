FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
LICENSE = "BSD-3-Clause"

SRC_URI:append:agilex5_dk_a5e065bb32aes1 = " file://0001-SM-TSN-CFG3-changes-for-TSN-REF-App.patch "

