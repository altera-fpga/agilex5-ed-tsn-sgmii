FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:agilex5_dk_a5e065bb32aes1 += "\
			file://agilex5_dk_a5e065bb32aes1_gsrd_ghrd.core.rbf;name=agilex5_dk_a5e065bb32aes1_gsrd_core_cfg3 \
			"

SRC_URI[agilex5_dk_a5e065bb32aes1_gsrd_core_cfg3.sha256sum] += "920dca57d70edfabe26e91a5aa95247e2d2ba4a51106c34239e3d83c07e856fa"

